# Repository Gcraud-Shuffle/Gcraud-Shuffle-2026

## EAGLE design line/Hardware/GC_LINE_2026_INCHEON.brd

Schematic: GC_LINE_2026_INCHEON.sch

Parts:
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 57, 59, 60, 61, 63: ALS-PT19-315C/L177/TR8C1608; C1608
+3.3V: RED; LEDC1608X55N_FLAT-R
C1, C2, C5, C6, C7, C8, C9, C10, C14, C15, C17, C18, C19, C20, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C40, C41, C42, C43, C44, C45, C46, C47, C48: 0.1uF; C1608
C3, C11: 10uF; C1608
C4, C12: 22uf; C1608
C39: 22uf; CC:3
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70, D71, D72: RED; CHIPLED_0603
DEBUG_UART: S4B-XH-A
IC1: AZ1117CH-3.3TRG1; SOT230P700X180-4N
IC2, IC3, IC5, IC6, IC8, IC9, IC11, IC12, IC13, IC14, IC15, IC16, IC17, IC18, IC19, IC20, IC21, IC22, IC23, IC24, IC25, IC26, IC27, IC28, IC29, IC30, IC31, IC32, IC33, IC34: LM393DR2G; SOIC127P600X175-8N
J2: JST-XH-2PIN; B2B-XH-A
LED1: WS2812B-B; WS2812BB
MCLR: PINHD1X05L; 1X05L
PIC32MK1024MCM100: PIC32MK1024MCM100T-E_PT; QFP40P1400X1400X120-100N
Q2: BSS138; SOT95P240X120-3N
R1: 1k; R1608
R2, R3, R4, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R21, R22, R86, R87, R143, R146, R147, R148, R149, R150, R151, R152, R153, R154, R155, R156, R157, R158, R159, R160, R161, R162, R163, R164, R165, R166, R167, R168, R169, R170, R171, R174, R175, R176, R177, R178, R180, R181, R182, R183, R184, R186, R187, R189, R190, R191, R192, R194, R195, R197, R206, R207: 10k; R1608
R5: 3.8k; R1608
R18, R19, R20, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R85, R145, R172, R173, R198, R199, R200, R205, R208, R209: 220; R1608
R82, R83, R84, R88, R89, R90, R91, R92, R93, R94, R95, R96, R97, R98, R99, R100, R101, R102, R103, R104, R105, R106, R107, R108, R109, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120, R121, R122, R123, R124, R125, R126, R127, R128, R129, R130, R131, R132, R133, R134, R135, R136, R137, R138, R139, R140, R141, R142, R144, R196: 64k; R1608
U1: AZ1117H-ADJTRE1SOT-223_DIO; SOT-223_DIO
U$3: RESETABLEFUSE; R3216
U$9: MCP4018T-503E/LT; SOT65P210X110-6N
U$27, U$57: SS2040FL; SDO-123FL
UART1: JST-XH-4PIN; B4B-XH-A

Connections:
1-1: IC12.1 (OUTPUT_A), PIC32MK1024MCM100.48 (AN39/CVD39/RD15), R6.1
1-2: IC12.7 (OUTPUT_B), PIC32MK1024MCM100.49 (TDI/DAC3/AN26/CVD26/RPA8/SDA2/PMA9/RA8), R12.2
2-1: IC13.1 (OUTPUT_A), PIC32MK1024MCM100.47 (AN38/CVD38/RD14), R14.1
2-2: IC13.7 (OUTPUT_B), PIC32MK1024MCM100.61 (AN45/CVD45/RF5), R15.2
3-1: IC14.1 (OUTPUT_A), PIC32MK1024MCM100.66 (AN46/CVD46/RPA14/RA14), R16.1
3-2: IC14.7 (OUTPUT_B), PIC32MK1024MCM100.67 (AN47/CVD47/RPA15/RA15), R17.2
4-1: IC15.1 (OUTPUT_A), PIC32MK1024MCM100.68 (RD8), R21.1
4-2: IC15.7 (OUTPUT_B), PIC32MK1024MCM100.72 (OA5OUT/AN25/CVD25/C5IN4-/RPB7/SCK1/INT0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), R86.2
5-1: IC16.1 (OUTPUT_A), PIC32MK1024MCM100.73 (SOSCI/RPC13/RC13), R87.1
5-2: IC16.7 (OUTPUT_B), PIC32MK1024MCM100.74 (SOSCO/T1CK/RPB8/RB8), R146.2
6-1: IC17.1 (OUTPUT_A), PIC32MK1024MCM100.76 (TMS/OA5IN-/AN27/CVD27/LVDIN/C5IN1-/RPB9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), R147.1
6-2: IC17.7 (OUTPUT_B), PIC32MK1024MCM100.77 (RPC6/USBID2/PMA16/RC6), R148.2
7-1: IC18.1 (OUTPUT_A), PIC32MK1024MCM100.79 (PMD12/RD12), R149.1
7-2: IC18.7 (OUTPUT_B), PIC32MK1024MCM100.78 (RPC7/PMA17/RC7), R150.2
8-1: IC19.1 (OUTPUT_A), PIC32MK1024MCM100.80 (PMD13/RD13), R151.1
8-2: IC19.7 (OUTPUT_B), PIC32MK1024MCM100.81 (RPC8/PMWR/RC8), R152.2
9-1: IC20.1 (OUTPUT_A), PIC32MK1024MCM100.93 (RPB10/PWM3H/PMD0/RB10), R7.1
9-2: IC20.7 (OUTPUT_B), PIC32MK1024MCM100.94 (RPB11/PWM9H/PWM3L/PMD1/RB11), R8.2
10-1: IC21.1 (OUTPUT_A), PIC32MK1024MCM100.98 (RPB12/PWM2H/PMD2/RB12), R9.1
10-2: IC21.7 (OUTPUT_B), PIC32MK1024MCM100.99 (RPB13/PWM8H/PWM2L/CTPLS/PMD3/RB13), R10.2
11-1: IC22.1 (OUTPUT_A), PIC32MK1024MCM100.4 (RPB14/PWM1H/VBUSON1/PMD6/RB14), R11.1
11-2: IC22.7 (OUTPUT_B), PIC32MK1024MCM100.5 (RPB15/PWM7H/PWM1L/PMD7/RB15), R13.2
12-1: IC23.1 (OUTPUT_A), PIC32MK1024MCM100.6 (PWM11H/PWM5L/RD1), R153.1
12-2: IC23.7 (OUTPUT_B), PIC32MK1024MCM100.7 (PWM5H/RD2), R154.2
13-1: IC24.1 (OUTPUT_A), PIC32MK1024MCM100.11 (AN18/CVD18/RPG7/PWM10H/SCL1/PMA4/RG7), R155.1
13-2: IC24.7 (OUTPUT_B), PIC32MK1024MCM100.12 (AN17/CVD17/RPG8/SDA1/PMA3/RG8), R156.2
14-1: IC25.1 (OUTPUT_A), PIC32MK1024MCM100.26 (PGC1/OA1IN+/AN4/C1IN1+/C1IN3-/C2IN3-/RP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), R157.1
14-2: IC25.7 (OUTPUT_B), R158.2
15-1: IC26.1 (OUTPUT_A), PIC32MK1024MCM100.27 (PGD1/OA1IN-/AN5/CTCMP/C1IN1-/RTCC/RPB3/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), R159.1
15-2: IC26.7 (OUTPUT_B), PIC32MK1024MCM100.28 (VREF-/AN33/CVD33/PMA7/RF9), R160.2
16-1: IC28.1 (OUTPUT_A), PIC32MK1024MCM100.33 (OA3IN-/AN7/CVD7/C3IN1-/C4IN1-/RPC1/RC1), R161.1
16-2: IC28.7 (OUTPUT_B), PIC32MK1024MCM100.34 (OA3IN+/AN8/CVD8/C3IN1+/C3IN3-/RPC2/FLT3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), R162.2
+3.3V: 1.1 (C), 2.1 (C), 3.1 (C), 4.1 (C), 5.1 (C), 6.1 (C), 7.1 (C), 8.1 (C), 9.1 (C), 10.1 (C), 11.1 (C), 12.1 (C), 13.1 (C), 14.1 (C), 15.1 (C), 16.1 (C), 17.1 (C), 18.1 (C), 19.1 (C), 20.1 (C), 21.1 (C), 22.1 (C), 23.1 (C), 24.1 (C), 25.1 (C), 26.1 (C), 27.1 (C), 28.1 (C), 29.1 (C), 30.1 (C), 31.1 (C), 32.1 (C), 33.1 (C), 34.1 (C), 35.1 (C), 36.1 (C), 37.1 (C), 38.1 (C), 39.1 (C), 40.1 (C), 41.1 (C), 42.1 (C), 43.1 (C), 44.1 (C), 45.1 (C), 46.1 (C), 47.1 (C), 48.1 (C), 49.1 (C), 50.1 (C), 51.1 (C), 52.1 (C), 53.1 (C), 54.1 (C), 55.1 (C), 57.1 (C), 59.1 (C), 60.1 (C), 61.1 (C), 63.1 (C), C1.1, C2.2, C4.1, C5.2, C6.1, C7.1, C8.1, C9.2, C10.1, C14.1, C15.1, C17.2, C18.1, C19.1, C20.1, C22.1, C23.1, C24.1, C25.1, C26.1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
+5V: J2.1, U$3.1
ANALOG-1: 63.2 (E), PIC32MK1024MCM100.14 (AN16/CVD16/RPG9/PMA2/RG9), R196.2
B1: IC9.1 (OUTPUT_A), PIC32MK1024MCM100.21 (AN9/CVD9/RPA11/RA11), R176.1
B1-IN: 13.2 (E), 14.2 (E), IC9.2 (INPUTS_A-), R132.2, R133.2
B2: IC9.7 (OUTPUT_B), PIC32MK1024MCM100.20 (AN10/CVD10/RPA12/RA12), R177.2
B2-IN: 17.2 (E), 18.2 (E), IC9.6 (INPUTS_B-), R136.2, R137.2
B3: IC34.1 (OUTPUT_A), PIC32MK1024MCM100.19 (AN20/CVD20/RE9), R195.1
B3-IN: 15.2 (E), IC34.2 (INPUTS_A-), R134.2
B4: IC34.7 (OUTPUT_B), PIC32MK1024MCM100.18 (AN21/CVD21/RE8), R197.2
B4-IN: 16.2 (E), IC34.6 (INPUTS_B-), R135.2
BB1: IC31.1 (OUTPUT_A), PIC32MK1024MCM100.9 (RPD4/PWM6H/RD4), R186.1
BB2: IC31.7 (OUTPUT_B), PIC32MK1024MCM100.8 (RPD3/PWM12H/PWM6L/RD3), R187.2
BB3: IC29.7 (OUTPUT_B), PIC32MK1024MCM100.22 (OA2OUT/AN0/C2IN4-/C4IN3-/RPA0/RA0), R189.2
BR1-IN: 53.2 (E), IC31.2 (INPUTS_A-), R140.2
BR2-IN: 54.2 (E), IC31.6 (INPUTS_B-), R141.2
BR3-IN: 55.2 (E), IC29.6 (INPUTS_B-), R142.2
DAC: IC2.3 (INPUTS_A+), IC2.5 (INPUTS_B+), IC3.3 (INPUTS_A+), IC3.5 (INPUTS_B+), IC5.3 (INPUTS_A+), IC5.5 (INPUTS_B+), IC6.3 (INPUTS_A+), IC6.5 (INPUTS_B+), IC8.3 (INPUTS_A+), IC8.5 (INPUTS_B+), IC9.3 (INPUTS_A+), IC9.5 (INPUTS_B+), IC11.3 (INPUTS_A+), IC11.5 (INPUTS_B+), IC12.3 (INPUTS_A+), IC12.5 (INPUTS_B+), IC13.3 (INPUTS_A+), IC13.5 (INPUTS_B+), IC14.3 (INPUTS_A+), IC14.5 (INPUTS_B+), IC15.3 (INPUTS_A+), IC15.5 (INPUTS_B+), IC16.3 (INPUTS_A+), IC16.5 (INPUTS_B+), IC17.3 (INPUTS_A+), IC17.5 (INPUTS_B+), IC18.3 (INPUTS_A+), IC18.5 (INPUTS_B+), IC19.3 (INPUTS_A+), IC19.5 (INPUTS_B+), IC20.3 (INPUTS_A+), IC20.5 (INPUTS_B+), IC21.3 (INPUTS_A+), IC21.5 (INPUTS_B+), IC22.3 (INPUTS_A+), IC22.5 (INPUTS_B+), IC23.3 (INPUTS_A+), IC23.5 (INPUTS_B+), IC24.3 (INPUTS_A+), IC24.5 (INPUTS_B+), IC25.3 (INPUTS_A+), IC25.5 (INPUTS_B+), IC26.3 (INPUTS_A+), IC26.5 (INPUTS_B+), IC27.3 (INPUTS_A+), IC27.5 (INPUTS_B+), IC28.3 (INPUTS_A+), IC28.5 (INPUTS_B+), IC29.3 (INPUTS_A+), IC29.5 (INPUTS_B+), IC30.3 (INPUTS_A+), IC30.5 (INPUTS_B+), IC31.3 (INPUTS_A+), IC31.5 (INPUTS_B+), IC32.3 (INPUTS_A+), IC32.5 (INPUTS_B+), IC33.3 (INPUTS_A+), IC33.5 (INPUTS_B+), IC34.3 (INPUTS_A+), IC34.5 (INPUTS_B+), PIC32MK1024MCM100.71 (DAC2/AN48/CVD48/RPC10/PMA14/PMCS/RC10), R22.2
DI: PIC32MK1024MCM100.100 (TDO/PWM4H/PMD4/RA10), Q2.2 (S), R206.1
DI-OUT: LED1.4 (DIN), Q2.3 (D), R207.1
GND: +3.3V.C, C1.2, C2.1, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.1, C10.2, C11.2, C12.2, C14.2, C15.2, C17.1, C18.2, C19.2, C20.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.- (P$2-), C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, D1.C, D2.C, D3.C, D4.C, D5.C, D6.C, D7.C, D8.C, D9.C, D10.C, D11.C, D12.C, D13.C, D14.C, D15.C, D16.C, D17.C, D18.C, D19.C, D20.C, D21.C, D22.C, D23.C, D24.C, D25.C, D26.C, D27.C, D28.C, D29.C, D30.C, D31.C, D32.C, D33.C, D34.C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
L1: IC6.1 (OUTPUT_A), PIC32MK1024MCM100.3 (TCK/RPA7/PWM10H/PWM4L/PMD5/RA7), R170.1
L1-IN: 7.2 (E), IC6.2 (INPUTS_A-), R126.2
L2: IC6.7 (OUTPUT_B), PIC32MK1024MCM100.1 (AN23/CVD23/PWM7L/PMA23/RG15), R171.2
L2-IN: 8.2 (E), IC6.6 (INPUTS_B-), R127.2
L3: IC11.1 (OUTPUT_A), PIC32MK1024MCM100.97 (TRD0/PWM7H/PMA22/RG13), R163.1
L3-IN: 9.2 (E), IC11.2 (INPUTS_A-), R128.2
L4: IC11.7 (OUTPUT_B), PIC32MK1024MCM100.90 (RPG0/PMD8/RG0), R180.2
L4-IN: 10.2 (E), IC11.6 (INPUTS_B-), R129.2
L5: IC8.1 (OUTPUT_A), PIC32MK1024MCM100.89 (RPG1/PMD9/RG1), R174.1
L5-IN: 11.2 (E), IC8.2 (INPUTS_A-), R130.2
L6: IC8.7 (OUTPUT_B), PIC32MK1024MCM100.84 (RPC9/PMD15/RC9), R175.2
L6-IN: 12.2 (E), IC8.6 (INPUTS_B-), R131.2
L7: PIC32MK1024MCM100.83 (RPD6/PWM12L/PMD14/RD6)
L8: PIC32MK1024MCM100.82 (RPD5/PWM12H/PMRD/RD5)
LED_OUT: C12.1, R5.2, R18.2, R19.2, R20.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.2, R66.2, R67.2, R68.2, R69.2, R70.2, R71.2, R72.2, R73.2, R74.2, R75.2, R76.2, R77.2, R78.2, R79.2, R80.2, R81.2, R85.2, R145.2, R172.2, R173.2, R198.2, R199.2, R200.2, R205.2, R208.2, R209.2, U1.2 (OUTPUT), U1.4 (EPAD), U$27.P$2 (C)
LL1: IC32.1 (OUTPUT_A), PIC32MK1024MCM100.95 (TRD2/PWM8H/PMA20/RG14), R190.1
LL2: IC32.7 (OUTPUT_B), PIC32MK1024MCM100.92 (TRD3/PWM9L/PMA19/RF7), R191.2
LL3: IC3.1 (OUTPUT_A), PIC32MK1024MCM100.96 (TRD1/RPG12/PWM8L/PMA21/RG12), R192.1
LR1-IN: 59.2 (E), IC32.2 (INPUTS_A-), R82.2
LR2-IN: 60.2 (E), IC32.6 (INPUTS_B-), R83.2
LR3-IN: 61.2 (E), IC3.2 (INPUTS_A-), R84.2
LR4-IN: IC3.6 (INPUTS_B-)
MCLR: MCLR.1, PIC32MK1024MCM100.13 (!MCLR), R3.1
unnamed: +3.3V.A, R1.1
unnamed: D2.A, R55.1
unnamed: D3.A, R56.1
unnamed: D4.A, R57.1
unnamed: D5.A, R58.1
unnamed: D20.A, R23.1
unnamed: D21.A, R24.1
unnamed: D22.A, R25.1
unnamed: D24.A, R27.1
unnamed: D25.A, R28.1
unnamed: D26.A, R29.1
unnamed: D27.A, R30.1
unnamed: D28.A, R31.1
unnamed: D29.A, R32.1
unnamed: D30.A, R33.1
unnamed: D31.A, R34.1
unnamed: D32.A, R35.1
unnamed: D33.A, R36.1
unnamed: D35.A, R38.1
unnamed: D34.A, R37.1
unnamed: D23.A, R26.1
unnamed: D36.A, R39.1
unnamed: D37.A, R40.1
unnamed: D38.A, R41.1
unnamed: D6.A, R59.1
unnamed: D39.A, R42.1
unnamed: D40.A, R43.1
unnamed: D41.A, R44.1
unnamed: D42.A, R45.1
unnamed: D43.A, R46.1
unnamed: D44.A, R47.1
unnamed: D45.A, R48.1
unnamed: D46.A, R49.1
unnamed: D47.A, R50.1
unnamed: D48.A, R51.1
unnamed: D49.A, R52.1
unnamed: D50.A, R53.1
unnamed: D51.A, R54.1
unnamed: D7.A, R60.1
unnamed: D8.A, R61.1
unnamed: D9.A, R62.1
unnamed: D10.A, R63.1
unnamed: D11.A, R64.1
unnamed: D12.A, R65.1
unnamed: D13.A, R66.1
unnamed: D14.A, R67.1
unnamed: D15.A, R68.1
unnamed: D16.A, R69.1
unnamed: D17.A, R70.1
unnamed: D18.A, R71.1
unnamed: D19.A, R72.1
unnamed: D52.A, R73.1
unnamed: D53.A, R74.1
unnamed: D54.A, R75.1
unnamed: D1.A, R76.1
unnamed: D56.A, R78.1
unnamed: R5.1, U1.1 (ADJ/GND), U$9.5 (W)
unnamed: D57.A, R79.1
unnamed: D58.A, R80.1
unnamed: D59.A, R81.1
unnamed: D64.A, R205.1
unnamed: D55.A, R77.1
unnamed: D61.A, R199.1
unnamed: D62.A, R20.1
unnamed: D65.A, R208.1
unnamed: U$3.2, U$57.P$1 (A)
unnamed: D60.A, R198.1
unnamed: D66.A, R209.1
unnamed: D63.A, R200.1
unnamed: D67.A, R145.1
unnamed: D68.A, R172.1
unnamed: D69.A, R173.1
unnamed: D70.A, R18.1
unnamed: D71.A, R19.1
unnamed: D72.A, R85.1
unnamed: PIC32MK1024MCM100.56 (D1-), R178.1
unnamed: PIC32MK1024MCM100.57 (D1+), R167.1
unnamed: PIC32MK1024MCM100.59 (D2-), R143.1
unnamed: PIC32MK1024MCM100.60 (D2+), R166.1
OUT_5V: C3.1, C11.1, C47.1, IC1.3 (INPUT), LED1.1 (VDD), R207.2, U1.3 (INPUT), U$57.P$2 (C)
PGC: MCLR.5, PIC32MK1024MCM100.25 (PGC3/OA1OUT/AN3/C1IN4-/C4IN2-/RPB1/CTED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)
PGD: MCLR.4, PIC32MK1024MCM100.24 (PGD3/OA2IN-/AN2/C2IN1-/RPB0/CTED2/RB0)
R1: IC27.1 (OUTPUT_A), PIC32MK1024MCM100.35 (AN11/CVD11/C1IN2-/FLT4/PMA12/RC11), R164.1
R1-IN: 1.2 (E), IC27.2 (INPUTS_A-), R120.2
R2: IC27.7 (OUTPUT_B), PIC32MK1024MCM100.38 (AN35/CVD35/RG11), R165.2
R2-IN: 2.2 (E), IC27.6 (INPUTS_B-), R121.2
R3: IC33.1 (OUTPUT_A), PIC32MK1024MCM100.29 (VREF+/AN34/CVD34/PMA6/RF10), R181.1
R3-IN: 3.2 (E), IC33.2 (INPUTS_A-), R122.2
R4: IC33.7 (OUTPUT_B), PIC32MK1024MCM100.32 (OA3OUT/AN6/CVD6/C3IN4-/C4IN1+/C4IN4-/RP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), R194.2
R4-IN: 4.2 (E), IC33.6 (INPUTS_B-), R123.2
R5: IC5.1 (OUTPUT_A), PIC32MK1024MCM100.52 (AN40/CVD40/RPE0/RE0), R168.1
R5-IN: 5.2 (E), IC5.2 (INPUTS_A-), R124.2
R6: IC5.7 (OUTPUT_B), PIC32MK1024MCM100.53 (AN41/CVD41/RPE1/RE1), R169.2
R6-IN: 6.2 (E), IC5.6 (INPUTS_B-), R125.2
RR1: IC2.1 (OUTPUT_A), PIC32MK1024MCM100.50 (FLT15/RPB4/SCL2/PMA8/RB4), R182.1
RR1-IN: 51.2 (E), IC2.2 (INPUTS_A-), R138.2
RR2: IC2.7 (OUTPUT_B), PIC32MK1024MCM100.40 (AN37/CVD37/RF12), R183.2
RR2-IN: 52.2 (E), IC2.6 (INPUTS_B-), R139.2
RR3: IC30.1 (OUTPUT_A), PIC32MK1024MCM100.51 (OA5IN+/DAC1/AN24/CVD24/C5IN1+/C5IN3-/RP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), R184.1
RR3-IN: 57.2 (E), IC30.2 (INPUTS_A-), R144.2
RR4: PIC32MK1024MCM100.39 (AN36/CVD36/RF13)
S1-IN: 19.2 (E), IC12.2 (INPUTS_A-), R88.2
S2-IN: 20.2 (E), IC12.6 (INPUTS_B-), R89.2
S3-IN: 21.2 (E), IC13.2 (INPUTS_A-), R90.2
S4-IN: 22.2 (E), IC13.6 (INPUTS_B-), R91.2
S5-IN: 23.2 (E), IC14.2 (INPUTS_A-), R92.2
S6-IN: 24.2 (E), IC14.6 (INPUTS_B-), R93.2
S7-IN: 25.2 (E), IC15.2 (INPUTS_A-), R94.2
S8-IN: 26.2 (E), IC15.6 (INPUTS_B-), R95.2
S9-IN: 27.2 (E), IC16.2 (INPUTS_A-), R96.2
S10-IN: 28.2 (E), IC16.6 (INPUTS_B-), R97.2
S11-IN: 29.2 (E), IC17.2 (INPUTS_A-), R98.2
S12-IN: 30.2 (E), IC17.6 (INPUTS_B-), R99.2
S13-IN: 31.2 (E), IC18.2 (INPUTS_A-), R100.2
S14-IN: 32.2 (E), IC18.6 (INPUTS_B-), R101.2
S15-IN: 33.2 (E), IC19.2 (INPUTS_A-), R102.2
S16-IN: 34.2 (E), IC19.6 (INPUTS_B-), R103.2
S17-IN: 35.2 (E), IC20.2 (INPUTS_A-), R104.2
S18-IN: 36.2 (E), IC20.6 (INPUTS_B-), R105.2
S19-IN: 37.2 (E), IC21.2 (INPUTS_A-), R106.2
S20-IN: 38.2 (E), IC21.6 (INPUTS_B-), R107.2
S21-IN: 39.2 (E), IC22.2 (INPUTS_A-), R108.2
S22-IN: 40.2 (E), IC22.6 (INPUTS_B-), R109.2
S23-IN: 41.2 (E), IC23.2 (INPUTS_A-), R110.2
S24-IN: 42.2 (E), IC23.6 (INPUTS_B-), R111.2
S25-IN: 43.2 (E), IC24.2 (INPUTS_A-), R112.2
S26-IN: 44.2 (E), IC24.6 (INPUTS_B-), R113.2
S27-IN: 45.2 (E), IC25.2 (INPUTS_A-), R114.2
S28-IN: 46.2 (E), IC25.6 (INPUTS_B-), R115.2
S29-IN: 47.2 (E), IC26.2 (INPUTS_A-), R116.2
S30-IN: 48.2 (E), IC26.6 (INPUTS_B-), R117.2
S31-IN: 49.2 (E), IC28.2 (INPUTS_A-), R118.2
S32-IN: 50.2 (E), IC28.6 (INPUTS_B-), R119.2
SCL3: PIC32MK1024MCM100.70 (PGC2/RPB6/SCL3/SCK2/PMA15/RB6), R4.1, U$9.3 (SCL)
SDA3: PIC32MK1024MCM100.69 (PGD2/RPB5/SDA3/USBID1/RB5), R2.1, U$9.4 (SDA)
U1-RX: PIC32MK1024MCM100.87 (RPF0/PWM11H/PMD11/RF0), UART1.3
U1-TX: PIC32MK1024MCM100.88 (RPF1/PWM11L/PMD10/RF1), UART1.2
U5-RX: DEBUG_UART.3, PIC32MK1024MCM100.64 (OSCO/CLKO/RPC15/RC15)
U5-TX: DEBUG_UART.2, PIC32MK1024MCM100.63 (OSCI/CLKI/AN49/CVD49/RPC12/RC12)

Notes on the sheet:
R5の値を変更

Board: 4 copper layers, 193.0 x 164.0 mm, 423 parts (264 on the bottom side), 211 nets.

Other parts of the board:
U$50: JLCPCB

## Code that names these connections

File line/Firmware/GC_LINE_2026_INCHEON.X/line_sensor.hpp:

/*
 * File:   line_sensor.hpp
 * Author: takum
 *
 * Created on March 9, 2026, 2:32 PM
 */

#ifndef LINE_SENSOR_HPP
#define LINE_SENSOR_HPP

#include <stdint.h>

#include "definitions.h"

extern uint16_t ANALOG_VALUE;

extern volatile uint32_t *S_port[];
extern uint32_t S_mask[];
#define get_Angel(i) (!(bool)(*S_port[(i)] & S_mask[(i)]))

#define get_out_val(I, M, E) ((I) ? 3 : ((M) ? 2 : ((E) ? 1 : 0)))

#define AngelA (~PORTA & 0xC102)  // 4:RA1,RA8,RA14,RA15
#define AngelB (~PORTB & 0xFF8C)  // 11:RB2,RB3,RB7,RB8,RB9,RB10,RB11,RB12,RB13,RB14,RB15
#define AngelC (~PORTC & 0x21C6)  // 6:RC1,RC2,RC6,RC7,RC8,RC13
#define AngelD (~PORTD & 0xF106)  // 7:RD1,RD2,RD8,RD12,RD13,RD14,RD15
#define AngelE 0                  // 0:
#define AngelF (~PORTF & 0x0220)  // 2:RF5,RF9
#define AngelG (~PORTG & 0x0180)  // 2:RG7,RG8

#define Angel_or ((bool)(AngelA | AngelB | AngelC | AngelD | AngelE | AngelF | AngelG))

#define RI (!PORTBbits.RB4)                                                                                             // inside : RB4
#define RM (!PORTFbits.RF12)                                                                                            // middle : RF12
#define RE ((bool)((~PORTA & 0x0010) | (~PORTC & 0x0801) | (~PORTE & 0x0003) | (~PORTF & 0x0400) | (~PORTG & 0x0800)))  // edge : RA4, RC0, RC11, RE0, RE1, RF10, RG11
#define R get_out_val(RI, RM, RE)

#define LI (!PORTGbits.RG14)                                                                                            // inside : RG14
#define LM (!PORTFbits.RF7)                                                                                             // middle : RF7
#define LE ((bool)((~PORTA & 0x0080) | (~PORTC & 0x0200) | (~PORTG & 0xB003)))                                          // edge : RA7, RC9, RG0, RG1, RG12, RG13, RG15
#define L get_out_val(LI, LM, LE)

#define BI (!PORTDbits.RD4)                                                                                             // inside : RD4
#define BM (!PORTDbits.RD3)                                                                                             // middle : RD3
#define BE ((bool)((~PORTA & 0x1801) | (~PORTE & 0x0300)))                                                              // edge : RA0, RA11, RA12, RE8, RE9
#define B (get_out_val(BI, BM, BE))

#endif /* LINE_SENSOR_HPP */

## Commit log (part)

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2026-06-24 change yellow threshold
2026-06-24 toriaezu
2026-06-24 6/24kaeru
2026-06-25 ボールホールド時のラインアウトするバグの解消
2026-06-27 6/27
2026-06-29 add IR and mecha
2026-06-30 change line
2026-06-30 updateFSM

Notices in the files:
parts and their libraries:
COPYRIGHT: Copyright (C) 2025 Ultra Librarian. All rights reserved.
